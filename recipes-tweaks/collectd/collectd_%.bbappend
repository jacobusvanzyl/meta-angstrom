PACKAGECONFIG:append_angstrom = " iptables libatasmart snmp sensors"
